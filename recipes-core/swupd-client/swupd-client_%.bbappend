PACKAGE_CONFIG_remove = "stateless"
